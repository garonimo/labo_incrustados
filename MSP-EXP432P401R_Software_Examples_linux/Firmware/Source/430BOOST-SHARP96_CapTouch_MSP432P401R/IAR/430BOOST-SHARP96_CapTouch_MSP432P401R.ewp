# IAR project 430BOOST-SHARP96_CapTouch_MSP432P401R.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ewarm
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\TexasInstruments; $TOOLKIT_DIR$\CMSIS\Include; ..\CTSLibrary; ..\GrLib\grlib; ..\GrLib\fonts; ..\LcdDriver; ..\Preloaded_Images; ..\driverlib\MSP432P4xx; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 430BOOST-SHARP96_CapTouch_MSP432P401R.srec
  ILINK.IlinkOutputFile: 430BOOST-SHARP96_CapTouch_MSP432P401R.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: ClockApp.c ClockApp.h CTS_LCDSliders.c CTS_LCDSliders.h Game.c Game.h msp432p4xx_EXP.c msp432p4xx_EXP.h myTimer.c myTimer.h structure.c structure.h system_msp432p401r.c UpdateDisplay.c UpdateDisplay.h
    ../driverlib/MSP432P4xx/ewarm/: msp432p4xx_driverlib.a
    ./: startup_msp432p401r_ewarm.c
  group CTSLibrary
    ../CTSLibrary/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h
  group GrLib/fonts
    ../GrLib/fonts/: fontcmss12.c fontcmss32.c
  group GrLib/grlib
    ../GrLib/grlib/: button.c button.h checkbox.c checkbox.h circle.c context.c display.c grlib.h image.c imageButton.c imageButton.h line.c radioButton.c radioButton.h rectangle.c string.c
  group LcdDriver
    ../LcdDriver/: Sharp96x96.c Sharp96x96.h Sharp96x96utils.c Sharp96x96utils.h
  group Preloaded_Images
    ../Preloaded_Images/: images.h LPRocket_96x37.c TI_Logo_69x64.c
