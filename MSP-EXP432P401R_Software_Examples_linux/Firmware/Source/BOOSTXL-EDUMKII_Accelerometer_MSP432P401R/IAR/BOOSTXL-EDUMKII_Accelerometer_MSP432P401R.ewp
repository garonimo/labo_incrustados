# IAR project BOOSTXL-EDUMKII_Accelerometer_MSP432P401R.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ewarm
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\TexasInstruments; $TOOLKIT_DIR$\CMSIS\Include; ..\driverlib\MSP432P4xx; ..\GrLib\fonts; ..\GrLib\grlib; ..\LcdDriver; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BOOSTXL-EDUMKII_Accelerometer_MSP432P401R.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../: main.c
    ./: startup_msp432p401r_ewarm.c system_msp432p401r.c
  group driverlib/MSP432P4xx
    ../driverlib/MSP432P4xx/: adc14.c adc14.h aes256.c aes256.h comp_e.c comp_e.h cpu.c cpu.h crc32.c crc32.h cs.c cs.h debug.h dma.c dma.h driverlib.h eusci.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pcm.c pcm.h pmap.c pmap.h pss.c pss.h ref_a.c ref_a.h reset.c reset.h rom.h rom_map.h rtc_c.c rtc_c.h spi.c spi.h sysctl.c sysctl.h systick.c systick.h timer32.c timer32.h timer_a.c timer_a.h uart.c uart.h wdt_a.c wdt_a.h
  group GrLib/fonts
    ../GrLib/fonts/: fontfixed6x8.c
  group GrLib/grlib
    ../GrLib/grlib/: button.c button.h checkbox.c checkbox.h circle.c context.c display.c grlib.h image.c imageButton.c imageButton.h line.c radioButton.c radioButton.h rectangle.c string.c
  group LcdDriver
    ../LcdDriver/: Crystalfontz128x128_ST7735.c Crystalfontz128x128_ST7735.h HAL_MSP_EXP432P401R_Crystalfontz128x128_ST7735.c HAL_MSP_EXP432P401R_Crystalfontz128x128_ST7735.h
