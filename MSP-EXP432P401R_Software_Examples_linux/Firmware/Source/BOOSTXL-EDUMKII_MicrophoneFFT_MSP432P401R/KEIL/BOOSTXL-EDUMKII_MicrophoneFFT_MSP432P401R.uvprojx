# Keil uVision project BOOSTXL-EDUMKII_MicrophoneFFT_MSP432P401R.uvprojx, settings and files
target BOOSTXL-EDUMKII_MicrophoneFFT_MSP432P401R (5060020::V5.06 (build 20)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BOOSTXL-EDUMKII_MicrophoneFFT_MSP432P401R
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil ARM_MATH_CM4
  c include: ..\;..\driverlib\MSP432P4xx;..\GrLib\fonts;..\GrLib\grlib;..\LcdDriver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group source
    ../: main.c
  group driverlib
    ../driverlib/MSP432P4xx/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group fonts
    ../GrLib/fonts/: fontfixed6x8.c
  group grlib
    ../GrLib/grlib/: button.c checkbox.c circle.c context.c display.c image.c imageButton.c line.c radioButton.c rectangle.c string.c
  group LcdDriver
    ../LcdDriver/: Crystalfontz128x128_ST7735.c HAL_MSP_EXP432P401R_Crystalfontz128x128_ST7735.c
software components: CMSIS:CORE 4.2.0, CMSIS:DSP 1.4.6, Device:Startup 1.0.1
