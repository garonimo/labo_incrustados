# IAR project 430BOOST-SENSE1_CapTouch_MSP432P401R.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ewarm
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\TexasInstruments; $TOOLKIT_DIR$\CMSIS\Include; ..\CTSLibrary; ..\driverlib\MSP432P4xx; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: 430BOOST-SENSE1_CapTouch_MSP432P401R.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: CapTouchBoosterPack_UserExperience.c structure.c structure.h system_msp432p401r.c uart.c uart.h
    ../driverlib/MSP432P4xx/ewarm/: msp432p4xx_driverlib.a
    ./: startup_msp432p401r_ewarm.c
  group CTSLibrary
    ../CTSLibrary/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h
